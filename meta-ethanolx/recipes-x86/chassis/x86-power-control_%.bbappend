FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Amd-power-control-modifications-for-EthanolX.patch"

SRCREV = "e63dea0875a70ff50f430a4bdc84b646a56b9ce7"
