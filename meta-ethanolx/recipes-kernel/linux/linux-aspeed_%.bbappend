FILESEXTRAPATHS_prepend := "${THISDIR}/linux-aspeed:"
SRC_URI += "file://ethanolx.cfg \
            file://0001-ARM-dts-aspeed-Initial-device-tree-for-AMD-EthanolX.patch"
